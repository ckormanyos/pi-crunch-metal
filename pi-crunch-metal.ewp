# IAR project pi-crunch-metal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 25
  General.FPU2: 2
  ICCARM.CCIncludePath2: src; src\mcal\bcm2835_raspi_b
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: kernel.img
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: pi-crunch-metal.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: src\mcal\bcm2835_raspi_b; src
  group src/math/constants
    src/math/constants/: constants_pi_control_for_decwide_t.h
  group src/math/wide_decimal
    src/math/wide_decimal/: decwide_t.h decwide_t_detail_fft.h decwide_t_detail_helper.h decwide_t_detail_karatsuba.h
  group src/mcal
    src/mcal/: mcal_cxx_completion.cpp mcal_helper.h mcal_reg_access_dynamic.h mcal_reg_access_static.h
  group src/mcal/bcm2835_raspi_b
    src/mcal/bcm2835_raspi_b/: mcal_cpu.cpp mcal_cpu.h mcal_cpu_detail_secure.c mcal_cpu_detail_secure.h mcal_gpt.cpp mcal_gpt.h mcal_irq.cpp mcal_irq.h mcal_lcd.cpp mcal_lcd.h mcal_lcd_st7066u_newhaven_0216k1z.h mcal_led.cpp mcal_led.h mcal_port.cpp mcal_port.h mcal_port_expander_microchip_mcp23s17.h mcal_port_pin_dummy.h mcal_reg.h mcal_reg.s mcal_spi.cpp mcal_spi.h
  group src/mcal_lcd
    src/mcal_lcd/: mcal_lcd_base.h mcal_lcd_console.h
  group src/mcal_led
    src/mcal_led/: mcal_led_base.h mcal_led_boolean_state_base.h mcal_led_console.h mcal_led_port.h mcal_led_port_inverted.h mcal_led_pwm.h
  group src/mcal_spi
    src/mcal_spi/: mcal_spi_software_dummy.h mcal_spi_software_port_driver.h
  group src/sys/start
    src/sys/start/: sys_start.cpp
  group src/util/memory
    src/util/memory/: util_n_slot_array_allocator.h
  group src/util/utility
    src/util/utility/: util_baselexical_cast.h util_communication.h util_dynamic_array.h util_lexical_cast.h util_noncopyable.h util_numeric_cast.h util_time.h util_two_part_data_manipulation.h util_utype_helper.h
